**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on May 28, 96
* Model format: SPICE3

*1 = A1, 2 = K, 3 = A2
.SUBCKT 20clq045 1 2 3
D1 1 2 D20clq045
D2 3 2 D20clq045

.MODEL D20clq045 d
+(
+		IS=5.55194e-10
+		RS=0.01
+		N=0.736126
+		EG=0.6
+		XTI=0.5
+		BV=45
+		IBV=0.005
+		CJO=2.42073e-09
+		VJ=0.470122
+		M=0.477502
+		FC=0.5
+		TT=0
+		KF=0
+		AF=1
+)

.ENDS 20clq045
