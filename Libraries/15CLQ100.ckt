**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on May 28, 96
* Model format: SPICE3
* 1 = K, 2 = A1, 3 = A2
.SUBCKT 15clq100 1 2 3
D1 2 1 D15clq100
D2 3 1 D15clq100

.MODEL D15clq100 d
+(
+		IS=6.44968e-05
+		RS=0.014091
+		N=2
+		EG=0.996757
+		XTI=0.5
+		BV=100
+		IBV=0.005
+		CJO=1.38463e-09
+		VJ=0.4
+		M=0.466344
+		FC=0.5
+		TT=0
+		KF=0
+		AF=1
+)

.ENDS 15clq100
